Commit message: Add files via upload

File: seguidor/robot_bruno/vascomovel.xacro (robot description, xacro)
@@ -42,5 +42,5 @@
   </link>
   <gazebo reference="corpo_link">
-    <material>Gazebo/Black</material>
+    <material>Gazebo/Grey</material>
   </gazebo>
   <!-- roda esquerda -->
